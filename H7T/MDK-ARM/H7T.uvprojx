# Keil uVision project H7T.uvprojx, settings and files
target H7T (6180000::V6.18::ARMCLANG)
  device: STM32H743XIHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: H7T +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=6 v6LangP=4 wLevel=3
  c define: USE_HAL_DRIVER,STM32H743xx
  c include: ../Core/Inc;  ../Drivers/STM32H7xx_HAL_Driver/Inc;  ../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;  ../Drivers/CMSIS/Device/ST/STM32H7xx/Include;  ../Drivers/CMSIS/Include;  ..\USER;  ..\lvgl;  ..\lvgl\examples\porting;  ..\lvgl\src;  ../Middlewares/Third_Party/FreeRTOS/Source/include;  ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;  ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;  ..\GUI\generated;  ..\GUI;  ..\GUI\generated\guider_customer_fonts;  ..\GUI\generated\guider_fonts;  ..\GUI\generated\images;  ..\GUI\custom
  asm include: ..\Core\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Application/MDK-ARM
    ./: startup_stm32h743xx.s
  group Application/User/Core
    ../USER/: sdram_fmc_drv.c lcd_rgb_ltdc_drv.c GT9157.c font24.c
    ../Core/Src/: main.c gpio.c freertos.c dma2d.c fmc.c i2c.c ltdc.c stm32h7xx_it.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_cortex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_dma2d.c stm32h7xx_ll_fmc.c stm32h7xx_hal_sdram.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_ltdc_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group lvgl
    ../lvgl/src/core/: lv_disp.c lv_disp.h lv_event.c lv_event.h lv_group.c lv_group.h lv_indev.c lv_indev.h lv_indev_scroll.c lv_indev_scroll.h lv_obj.c lv_obj.h lv_obj_class.c lv_obj_class.h lv_obj_draw.c lv_obj_draw.h lv_obj_pos.c lv_obj_pos.h lv_obj_scroll.c lv_obj_scroll.h lv_obj_style.c lv_obj_style.h lv_obj_style_gen.c lv_obj_style_gen.h lv_obj_tree.c lv_obj_tree.h lv_refr.c lv_refr.h lv_theme.c lv_theme.h
    ../lvgl/src/draw/arm2d/: lv_gpu_arm2d.c lv_gpu_arm2d.h
    ../lvgl/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl.h lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_composite.h lv_draw_sdl_img.c lv_draw_sdl_img.h lv_draw_sdl_label.c lv_draw_sdl_layer.c lv_draw_sdl_layer.h lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_mask.h lv_draw_sdl_polygon.c lv_draw_sdl_priv.h lv_draw_sdl_rect.c lv_draw_sdl_rect.h lv_draw_sdl_stack_blur.c lv_draw_sdl_stack_blur.h lv_draw_sdl_texture_cache.c lv_draw_sdl_texture_cache.h lv_draw_sdl_utils.c lv_draw_sdl_utils.h
    ../lvgl/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c lv_gpu_stm32_dma2d.h
    ../lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw.h lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_blend.h lv_draw_sw_dither.c lv_draw_sw_dither.h lv_draw_sw_gradient.c lv_draw_sw_gradient.h lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    ../lvgl/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.c lv_gpu_swm341_dma2d.h
    ../lvgl/src/draw/: lv_draw.c lv_draw.h lv_draw_arc.c lv_draw_arc.h lv_draw_img.c lv_draw_img.h lv_draw_label.c lv_draw_label.h lv_draw_layer.c lv_draw_layer.h lv_draw_line.c lv_draw_line.h lv_draw_mask.c lv_draw_mask.h lv_draw_rect.c lv_draw_rect.h lv_draw_transform.c lv_draw_transform.h lv_draw_triangle.c lv_draw_triangle.h lv_img_buf.c lv_img_buf.h lv_img_cache.c lv_img_cache.h lv_img_decoder.c lv_img_decoder.h
    ../lvgl/src/extra/layouts/flex/: lv_flex.c lv_flex.h
    ../lvgl/src/extra/layouts/grid/: lv_grid.c lv_grid.h
    ../lvgl/src/extra/layouts/: lv_layouts.h
    ../lvgl/src/extra/libs/bmp/: lv_bmp.c lv_bmp.h
    ../lvgl/src/extra/libs/ffmpeg/: lv_ffmpeg.c lv_ffmpeg.h
    ../lvgl/src/extra/libs/freetype/: lv_freetype.c lv_freetype.h
    ../lvgl/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c lv_fsdrv.h
    ../lvgl/src/extra/libs/gif/: gifdec.c gifdec.h lv_gif.c lv_gif.h
    ../lvgl/src/extra/libs/png/: lodepng.c lodepng.h lv_png.c lv_png.h
    ../lvgl/src/extra/libs/qrcode/: lv_qrcode.c lv_qrcode.h qrcodegen.c qrcodegen.h
    ../lvgl/src/extra/libs/rlottie/: lv_rlottie.c lv_rlottie.h
    ../lvgl/src/extra/libs/sjpg/: lv_sjpg.c lv_sjpg.h tjpgd.c tjpgd.h tjpgdcnf.h
    ../lvgl/src/extra/libs/: lv_libs.h
    ../lvgl/src/extra/others/fragment/: lv_fragment.c lv_fragment.h lv_fragment_manager.c
    ../lvgl/src/extra/others/gridnav/: lv_gridnav.c lv_gridnav.h
    ../lvgl/src/extra/others/ime/: lv_ime_pinyin.c lv_ime_pinyin.h
    ../lvgl/src/extra/others/imgfont/: lv_imgfont.c lv_imgfont.h
    ../lvgl/src/extra/others/monkey/: lv_monkey.c lv_monkey.h
    ../lvgl/src/extra/others/msg/: lv_msg.c lv_msg.h
    ../lvgl/src/extra/others/snapshot/: lv_snapshot.c lv_snapshot.h
    ../lvgl/src/extra/others/: lv_others.h
    ../lvgl/src/extra/themes/basic/: lv_theme_basic.c lv_theme_basic.h
    ../lvgl/src/extra/themes/default/: lv_theme_default.c lv_theme_default.h
    ../lvgl/src/extra/themes/mono/: lv_theme_mono.c lv_theme_mono.h
    ../lvgl/src/extra/themes/: lv_themes.h
    ../lvgl/src/extra/widgets/animimg/: lv_animimg.c lv_animimg.h
    ../lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar.h lv_calendar_header_arrow.c lv_calendar_header_arrow.h lv_calendar_header_dropdown.c lv_calendar_header_dropdown.h
    ../lvgl/src/extra/widgets/chart/: lv_chart.c lv_chart.h
    ../lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c lv_colorwheel.h
    ../lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c lv_imgbtn.h
    ../lvgl/src/extra/widgets/keyboard/: lv_keyboard.c lv_keyboard.h
    ../lvgl/src/extra/widgets/led/: lv_led.c lv_led.h
    ../lvgl/src/extra/widgets/list/: lv_list.c lv_list.h
    ../lvgl/src/extra/widgets/menu/: lv_menu.c lv_menu.h
    ../lvgl/src/extra/widgets/meter/: lv_meter.c lv_meter.h
    ../lvgl/src/extra/widgets/msgbox/: lv_msgbox.c lv_msgbox.h
    ../lvgl/src/extra/widgets/span/: lv_span.c lv_span.h
    ../lvgl/src/extra/widgets/spinbox/: lv_spinbox.c lv_spinbox.h
    ../lvgl/src/extra/widgets/spinner/: lv_spinner.c lv_spinner.h
    ../lvgl/src/extra/widgets/tabview/: lv_tabview.c lv_tabview.h
    ../lvgl/src/extra/widgets/tileview/: lv_tileview.c lv_tileview.h
    ../lvgl/src/extra/widgets/win/: lv_win.c lv_win.h
    ../lvgl/src/extra/widgets/: lv_widgets.h
    ../lvgl/src/extra/: lv_extra.c lv_extra.h
    ../lvgl/src/font/: lv_font.c lv_font.h lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_fmt_txt.h lv_font_loader.c lv_font_loader.h lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c lv_symbol_def.h
    ../lvgl/src/hal/: lv_hal.h lv_hal_disp.c lv_hal_disp.h lv_hal_indev.c lv_hal_indev.h lv_hal_tick.c lv_hal_tick.h
    ../lvgl/src/misc/: lv_anim.c lv_anim.h lv_anim_timeline.c lv_anim_timeline.h lv_area.c lv_area.h lv_assert.h lv_async.c lv_async.h lv_bidi.c lv_bidi.h lv_color.c lv_color.h lv_fs.c lv_fs.h lv_gc.c lv_gc.h lv_ll.c lv_ll.h lv_log.c lv_log.h lv_lru.c lv_lru.h lv_math.c lv_math.h lv_mem.c lv_mem.h lv_printf.c lv_printf.h lv_style.c lv_style.h lv_style_gen.c lv_style_gen.h lv_templ.c lv_templ.h lv_timer.c lv_timer.h lv_tlsf.c lv_tlsf.h lv_txt.c lv_txt.h lv_txt_ap.c lv_txt_ap.h lv_types.h lv_utils.c lv_utils.h
    ../lvgl/src/widgets/: lv_arc.c lv_arc.h lv_bar.c lv_bar.h lv_btn.c lv_btn.h lv_btnmatrix.c lv_btnmatrix.h lv_canvas.c lv_canvas.h lv_checkbox.c lv_checkbox.h lv_dropdown.c lv_dropdown.h lv_img.c lv_img.h lv_label.c lv_label.h lv_line.c lv_line.h lv_objx_templ.c lv_objx_templ.h lv_roller.c lv_roller.h lv_slider.c lv_slider.h lv_switch.c lv_switch.h lv_table.c lv_table.h lv_textarea.c lv_textarea.h
    ../lvgl/src/: lv_api_map.h lv_conf_internal.h lv_conf_kconfig.h lvgl.h
    ../lvgl/src/draw/nxp/pxp/: lv_draw_pxp_blend.c lv_draw_pxp_blend.h lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp.h lv_gpu_nxp_pxp_osa.c lv_gpu_nxp_pxp_osa.h
    ../lvgl/src/draw/nxp/vglite/: lv_draw_vglite_arc.c lv_draw_vglite_arc.h lv_draw_vglite_blend.c lv_draw_vglite_blend.h lv_draw_vglite_rect.c lv_draw_vglite_rect.h lv_gpu_nxp_vglite.c lv_gpu_nxp_vglite.h
    ../lvgl/src/draw/nxp/: lv_gpu_nxp.c lv_gpu_nxp.h
    ../lvgl/src/extra/widgets/dclock/: lv_dclock.c lv_dclock.h
  group lvgl_port
    ../lvgl/examples/porting/: lv_port_disp_template.c lv_port_indev_template.c
    ../lvgl/: lv_conf.h lvgl.h
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group GUI/generated
    ../GUI/generated/: events_init.c events_init.h gui_guider.c gui_guider.h setup_scr_screen.c widgets_init.c widgets_init.h
    ../GUI/generated/images/: _20200329040230_BGeJU_0_alpha_153x97.c _pic_480x854.c screen_animimg_120200329040230_BGeJU_0.c screen_animimg_120200329040230_BGeJU_1.c screen_animimg_120200329040230_BGeJU_2.c screen_animimg_120200329040230_BGeJU_3.c screen_animimg_120200329040230_BGeJU_4.c screen_animimg_120200329040230_BGeJU_5.c screen_animimg_120200329040230_BGeJU_6.c screen_animimg_120200329040230_BGeJU_7.c screen_animimg_120200329040230_BGeJU_8.c screen_animimg_120200329040230_BGeJU_9.c screen_animimg_120200329040230_BGeJU_10.c screen_animimg_120200329040230_BGeJU_11.c screen_animimg_120200329040230_BGeJU_12.c screen_animimg_120200329040230_BGeJU_13.c screen_animimg_120200329040230_BGeJU_14.c screen_animimg_120200329040230_BGeJU_15.c screen_animimg_120200329040230_BGeJU_16.c screen_animimg_120200329040230_BGeJU_17.c screen_animimg_120200329040230_BGeJU_18.c screen_animimg_120200329040230_BGeJU_19.c screen_animimg_120200329040230_BGeJU_20.c screen_animimg_120200329040230_BGeJU_21.c screen_animimg_120200329040230_BGeJU_22.c screen_animimg_120200329040230_BGeJU_23.c screen_animimg_120200329040230_BGeJU_24.c screen_animimg_120200329040230_BGeJU_25.c screen_animimg_120200329040230_BGeJU_26.c screen_animimg_120200329040230_BGeJU_27.c screen_animimg_120200329040230_BGeJU_28.c screen_animimg_120200329040230_BGeJU_29.c screen_animimg_120200329040230_BGeJU_30.c screen_animimg_120200329040230_BGeJU_31.c screen_animimg_120200329040230_BGeJU_32.c screen_animimg_120200329040230_BGeJU_33.c screen_animimg_120200329040230_BGeJU_34.c
    ../GUI/generated/guider_fonts/: lv_font_Adventpro_regular_18.c lv_font_Adventpro_regular_24.c lv_font_Antonio_Regular_16.c lv_font_Antonio_Regular_21.c lv_font_Antonio_Regular_24.c lv_font_montserratMedium_12.c lv_font_montserratMedium_16.c lv_font_montserratMedium_24.c lv_font_SourceHanSerifSC_Regular_18.c lv_font_montserratMedium_37.c
    ../GUI/generated/guider_customer_fonts/: guider_customer_fonts.h
  group GUI/custom
    ../GUI/custom/: custom.c custom.h lv_conf_ext.h
software components: CMSIS:CORE 5.6.0, Compiler:I/O:STDERR 1.2.0
